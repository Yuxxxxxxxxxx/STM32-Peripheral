# Keil uVision project NewDevice.uvprojx, settings and files
target Cortex-M (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyDevice_stm32f407
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\firmware\cmsis\core;.\firmware\cmsis\device;.\firmware\driver\inc;.\driver\ctl_spi;.\driver\w25q
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group firmware
    ../9、W25Q128JV/firmware/cmsis/device/: system_stm32f4xx.c
    ../9、W25Q128JV/firmware/driver/src/: stm32f4xx_gpio.c stm32f4xx_spi.c
    ./firmware/driver/src/: stm32f4xx_rcc.c
  group driver
    ./driver/ctl_spi/: ctl_spi.c
    ./driver/w25q/: w25q.c
